# Keil uVision project ZHTC-Control.uvprojx, settings and files
target ZHTC-Control (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ZHTC-Control +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;..\mavlink;..\mavlink\ardupilotmega;..\mavlink\minimal;..\mavlink\common
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group User
    ../User/src/: app.c interrupt.c brt38_encoder.c modbus_rtu.c serial.c motor.c valve_control.c collect_task.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Mavlink
    ../mavlink/: checksum.h mavlink_conversions.h mavlink_get_info.h mavlink_helpers.h mavlink_sha256.h mavlink_types.h protocol.h
    ../mavlink/ardupilotmega/: ardupilotmega.h mavlink.h mavlink_msg_adap_tuning.h mavlink_msg_ahrs.h mavlink_msg_ahrs2.h mavlink_msg_ahrs3.h mavlink_msg_airspeed_autocal.h mavlink_msg_aoa_ssa.h mavlink_msg_ap_adc.h mavlink_msg_autopilot_version_request.h mavlink_msg_battery2.h mavlink_msg_camera_feedback.h mavlink_msg_camera_status.h mavlink_msg_compassmot_status.h mavlink_msg_data16.h mavlink_msg_data32.h mavlink_msg_data64.h mavlink_msg_data96.h mavlink_msg_deepstall.h mavlink_msg_device_op_read.h mavlink_msg_device_op_read_reply.h mavlink_msg_device_op_write.h mavlink_msg_device_op_write_reply.h mavlink_msg_digicam_configure.h mavlink_msg_digicam_control.h mavlink_msg_ekf_status_report.h mavlink_msg_esc_telemetry_1_to_4.h mavlink_msg_esc_telemetry_5_to_8.h mavlink_msg_esc_telemetry_9_to_12.h mavlink_msg_esc_telemetry_13_to_16.h mavlink_msg_esc_telemetry_17_to_20.h mavlink_msg_esc_telemetry_21_to_24.h mavlink_msg_esc_telemetry_25_to_28.h mavlink_msg_esc_telemetry_29_to_32.h mavlink_msg_fence_fetch_point.h mavlink_msg_fence_point.h mavlink_msg_gimbal_control.h mavlink_msg_gimbal_report.h mavlink_msg_gimbal_torque_cmd_report.h mavlink_msg_gopro_get_request.h mavlink_msg_gopro_get_response.h mavlink_msg_gopro_heartbeat.h mavlink_msg_gopro_set_request.h mavlink_msg_gopro_set_response.h mavlink_msg_hwstatus.h mavlink_msg_led_control.h mavlink_msg_limits_status.h mavlink_msg_mag_cal_progress.h mavlink_msg_mcu_status.h mavlink_msg_meminfo.h mavlink_msg_mount_configure.h mavlink_msg_mount_control.h mavlink_msg_mount_status.h mavlink_msg_obstacle_distance_3d.h mavlink_msg_osd_param_config.h mavlink_msg_osd_param_config_reply.h mavlink_msg_osd_param_show_config.h mavlink_msg_osd_param_show_config_reply.h mavlink_msg_pid_tuning.h mavlink_msg_radio.h mavlink_msg_rally_fetch_point.h mavlink_msg_rally_point.h mavlink_msg_rangefinder.h mavlink_msg_remote_log_block_status.h mavlink_msg_remote_log_data_block.h mavlink_msg_rpm.h mavlink_msg_secure_command.h mavlink_msg_secure_command_reply.h mavlink_msg_sensor_offsets.h mavlink_msg_set_mag_offsets.h mavlink_msg_simstate.h mavlink_msg_vision_position_delta.h mavlink_msg_water_depth.h mavlink_msg_wind.h testsuite.h version.h
    ../mavlink/common/: common.h mavlink.h mavlink_msg_actuator_control_target.h mavlink_msg_actuator_output_status.h mavlink_msg_adsb_vehicle.h mavlink_msg_ais_vessel.h mavlink_msg_altitude.h mavlink_msg_att_pos_mocap.h mavlink_msg_attitude.h mavlink_msg_attitude_quaternion.h mavlink_msg_attitude_quaternion_cov.h mavlink_msg_attitude_target.h mavlink_msg_auth_key.h mavlink_msg_autopilot_state_for_gimbal_device.h mavlink_msg_autopilot_version.h mavlink_msg_battery_status.h mavlink_msg_button_change.h mavlink_msg_camera_capture_status.h mavlink_msg_camera_image_captured.h mavlink_msg_camera_information.h mavlink_msg_camera_settings.h mavlink_msg_camera_trigger.h mavlink_msg_can_filter_modify.h mavlink_msg_can_frame.h mavlink_msg_canfd_frame.h mavlink_msg_change_operator_control.h mavlink_msg_change_operator_control_ack.h mavlink_msg_collision.h mavlink_msg_command_ack.h mavlink_msg_command_int.h mavlink_msg_command_long.h mavlink_msg_control_system_state.h mavlink_msg_data_stream.h mavlink_msg_data_transmission_handshake.h mavlink_msg_debug.h mavlink_msg_debug_float_array.h mavlink_msg_debug_vect.h mavlink_msg_distance_sensor.h mavlink_msg_efi_status.h mavlink_msg_encapsulated_data.h mavlink_msg_estimator_status.h mavlink_msg_extended_sys_state.h mavlink_msg_fence_status.h mavlink_msg_file_transfer_protocol.h mavlink_msg_flight_information.h mavlink_msg_follow_target.h mavlink_msg_generator_status.h mavlink_msg_gimbal_device_attitude_status.h mavlink_msg_gimbal_device_information.h mavlink_msg_gimbal_device_set_attitude.h mavlink_msg_global_position_int.h mavlink_msg_global_position_int_cov.h mavlink_msg_global_vision_position_estimate.h mavlink_msg_gps_global_origin.h mavlink_msg_gps_inject_data.h mavlink_msg_gps_input.h mavlink_msg_gps_raw_int.h mavlink_msg_gps_rtcm_data.h mavlink_msg_gps_rtk.h mavlink_msg_gps_status.h mavlink_msg_gps2_raw.h mavlink_msg_gps2_rtk.h mavlink_msg_high_latency.h mavlink_msg_high_latency2.h mavlink_msg_highres_imu.h mavlink_msg_hil_actuator_controls.h mavlink_msg_hil_controls.h mavlink_msg_hil_gps.h mavlink_msg_hil_optical_flow.h mavlink_msg_hil_rc_inputs_raw.h mavlink_msg_hil_sensor.h mavlink_msg_hil_state.h mavlink_msg_hil_state_quaternion.h mavlink_msg_home_position.h mavlink_msg_hygrometer_sensor.h mavlink_msg_isbd_link_status.h mavlink_msg_landing_target.h mavlink_msg_local_position_ned.h mavlink_msg_local_position_ned_cov.h mavlink_msg_local_position_ned_system_global_offset.h mavlink_msg_log_data.h mavlink_msg_log_entry.h mavlink_msg_log_erase.h mavlink_msg_log_request_data.h mavlink_msg_log_request_end.h mavlink_msg_log_request_list.h mavlink_msg_logging_ack.h mavlink_msg_logging_data.h mavlink_msg_logging_data_acked.h mavlink_msg_mag_cal_report.h mavlink_msg_manual_control.h mavlink_msg_manual_setpoint.h mavlink_msg_memory_vect.h mavlink_msg_message_interval.h mavlink_msg_mission_ack.h mavlink_msg_mission_clear_all.h mavlink_msg_mission_count.h mavlink_msg_mission_current.h mavlink_msg_mission_item.h mavlink_msg_mission_item_int.h mavlink_msg_mission_item_reached.h mavlink_msg_mission_request.h mavlink_msg_mission_request_int.h mavlink_msg_mission_request_list.h mavlink_msg_mission_request_partial_list.h mavlink_msg_mission_set_current.h mavlink_msg_mission_write_partial_list.h mavlink_msg_mount_orientation.h mavlink_msg_named_value_float.h mavlink_msg_named_value_int.h mavlink_msg_nav_controller_output.h mavlink_msg_obstacle_distance.h mavlink_msg_odometry.h mavlink_msg_open_drone_id_arm_status.h mavlink_msg_open_drone_id_authentication.h mavlink_msg_open_drone_id_basic_id.h mavlink_msg_open_drone_id_location.h mavlink_msg_open_drone_id_message_pack.h mavlink_msg_open_drone_id_operator_id.h mavlink_msg_open_drone_id_self_id.h mavlink_msg_open_drone_id_system.h mavlink_msg_open_drone_id_system_update.h mavlink_msg_optical_flow.h mavlink_msg_optical_flow_rad.h mavlink_msg_param_ext_ack.h mavlink_msg_param_ext_request_list.h mavlink_msg_param_ext_request_read.h mavlink_msg_param_ext_set.h mavlink_msg_param_ext_value.h mavlink_msg_param_map_rc.h mavlink_msg_param_request_list.h mavlink_msg_param_request_read.h mavlink_msg_param_set.h mavlink_msg_param_value.h mavlink_msg_ping.h mavlink_msg_play_tune.h mavlink_msg_position_target_global_int.h mavlink_msg_position_target_local_ned.h mavlink_msg_power_status.h mavlink_msg_radio_status.h mavlink_msg_raw_imu.h mavlink_msg_raw_pressure.h mavlink_msg_raw_rpm.h mavlink_msg_rc_channels.h mavlink_msg_rc_channels_override.h mavlink_msg_rc_channels_raw.h mavlink_msg_rc_channels_scaled.h mavlink_msg_request_data_stream.h mavlink_msg_resource_request.h mavlink_msg_safety_allowed_area.h mavlink_msg_safety_set_allowed_area.h mavlink_msg_scaled_imu.h mavlink_msg_scaled_imu2.h mavlink_msg_scaled_imu3.h mavlink_msg_scaled_pressure.h mavlink_msg_scaled_pressure2.h mavlink_msg_scaled_pressure3.h mavlink_msg_serial_control.h mavlink_msg_servo_output_raw.h mavlink_msg_set_actuator_control_target.h mavlink_msg_set_attitude_target.h mavlink_msg_set_gps_global_origin.h mavlink_msg_set_home_position.h mavlink_msg_set_mode.h mavlink_msg_set_position_target_global_int.h mavlink_msg_set_position_target_local_ned.h mavlink_msg_setup_signing.h mavlink_msg_sim_state.h mavlink_msg_smart_battery_info.h mavlink_msg_statustext.h mavlink_msg_storage_information.h mavlink_msg_sys_status.h mavlink_msg_system_time.h mavlink_msg_terrain_check.h mavlink_msg_terrain_data.h mavlink_msg_terrain_report.h mavlink_msg_terrain_request.h mavlink_msg_timesync.h mavlink_msg_tunnel.h mavlink_msg_uavcan_node_info.h mavlink_msg_uavcan_node_status.h mavlink_msg_utm_global_position.h mavlink_msg_v2_extension.h mavlink_msg_vfr_hud.h mavlink_msg_vibration.h mavlink_msg_vicon_position_estimate.h mavlink_msg_video_stream_information.h mavlink_msg_video_stream_status.h mavlink_msg_vision_position_estimate.h mavlink_msg_vision_speed_estimate.h mavlink_msg_wheel_distance.h mavlink_msg_wifi_config_ap.h mavlink_msg_winch_status.h mavlink_msg_wind_cov.h testsuite.h version.h
    ../mavlink/minimal/: mavlink.h mavlink_msg_heartbeat.h minimal.h testsuite.h version.h
software components: CMSIS:CORE 4.3.0
